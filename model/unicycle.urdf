Commit message: gymの方は最低限できたと思う

File: model/unicycle.urdf (robot description, URDF)
Before this commit: robot unicycle, 5 links, 4 joints
Links:
- link saddle_link: mass None -> 60
- link wheel_link: mass 1 -> 3
